# IAR project SensorTag.ewp, settings and files
configuration CC2541DK-Sensor (8051)
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\CC2541F256.i51
  ICC8051.CCDefines: BEACON_FEATURE; INT_HEAP_LEN=3072; HALNODEBUG; OSAL_CBTIMER_NUM_TASKS=1; HAL_AES_DMA=TRUE; HAL_DMA=TRUE; POWER_SAVING; HAL_LCD=FALSE; HAL_LED=TRUE; HAL_I2C=TRUE; HAL_ADC=FALSE; HAL_KEY=TRUE; HAL_UART=FALSE; HAL_HID=FALSE; HAL_SPI=FALSE; HAL_BUZZER=FALSE
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: ..\..\..\TI\Components\common; ..\..\..\TI\Components\include; ..\..\..\TI\Components\hal\include; ..\..\..\TI\Components\hal\target\CC2541ST; ..\..\..\TI\Components\osal\include; ..\..\..\TI\Components\services\saddr; ..\..\..\TI\Components\ble\include; ..\..\..\TI\Components\ble\controller\phy; ..\..\..\TI\Components\ble\controller\include; ..\..\..\TI\Components\ble\hci; ..\..\..\TI\Components\ble\host; ..\..\..\TI\Components\common\cc2540; ..\..\..\TI\Components\common\npi\npi_np; ..\..\..\TI\Profiles\Roles; ..\..\..\TI\Profiles\SensorProfile; ..\..\..\TI\Profiles\Keys; ..\..\..\TI\Profiles\DevInfo
  ICC8051.CCOptLevel: 0
  ICC8051.CCOptStrategy: 1
  ICC8051.IccLang: 0
  XLINK.XclFile: ..\..\..\TI\Components\common\cc2540\ti_51ew_cc2540b.xcl
configuration CC2541DK-Sensor-OAD-ImgA (8051)
  as the first configuration, except:
  ICC8051.CCDefines: BEACON_FEATURE; ADV_DATA_FLASH; FEATURE_OAD_BIM; HAL_IMAGE_A; FEATURE_OAD; OAD_KEEP_NV_PAGES; INT_HEAP_LEN=3072; HALNODEBUG; OSAL_CBTIMER_NUM_TASKS=1; HAL_AES_DMA=TRUE; HAL_DMA=TRUE; POWER_SAVING; HAL_LCD=FALSE; HAL_LED=TRUE; HAL_I2C=TRUE; HAL_ADC=FALSE
  ICC8051.CCIncludePath2: ..\..\..\TI\Components\common; ..\..\..\TI\Components\include; ..\..\..\TI\Components\hal\include; ..\..\..\TI\Components\hal\target\CC2541ST; ..\..\..\TI\Components\osal\include; ..\..\..\TI\Components\services\saddr; ..\..\..\TI\Components\ble\include; ..\..\..\TI\Components\ble\controller\phy; ..\..\..\TI\Components\ble\controller\include; ..\..\..\TI\Components\ble\hci; ..\..\..\TI\Components\ble\host; ..\..\..\TI\Components\common\cc2540; ..\..\..\TI\Components\common\npi\npi_np; ..\..\..\TI\Profiles\Roles; ..\..\..\TI\Profiles\SensorProfile; ..\..\..\TI\Profiles\Keys; ..\..\..\TI\Profiles\DevInfo; ..\..\..\TI\Profiles\Oad
  ICC8051.CCOptLevel: 3
  postbuild: "..\..\..\TI\Components\common\cc2540\cc254x_ubl_pp.bat" "$PROJ_DIR$" "ProdUBL" "CC2541DK-Sensor-OAD-ImgA\Exe\SensorTag"
  XLINK.XclFile: ..\..\..\TI\Components\common\cc2540\cc254x_f256_imgA.xcl
configuration CC2541DK-Sensor-OAD-ImgB (8051)
  as the first configuration, except:
  ICC8051.CCDefines: BEACON_FEATURE; FEATURE_OAD_BIM; HAL_IMAGE_B; FEATURE_OAD; OAD_KEEP_NV_PAGES; INT_HEAP_LEN=3072; HALNODEBUG; OSAL_CBTIMER_NUM_TASKS=1; HAL_AES_DMA=TRUE; HAL_DMA=TRUE; POWER_SAVING; HAL_LCD=FALSE; HAL_LED=TRUE; HAL_I2C=TRUE; HAL_ADC=FALSE
  ICC8051.CCIncludePath2: as above
  ICC8051.CCOptLevel: 3
  postbuild: "..\..\..\TI\Components\common\cc2540\cc254x_ubl_pp.bat" "$PROJ_DIR$" "ProdUBL" "CC2541DK-Sensor-OAD-ImgB\Exe\SensorTag"
  XLINK.XclFile: ..\..\..\TI\Components\common\cc2540\cc254x_f256_imgB.xcl
  group APP
    ../Source/: OSAL_SensorTag.c SensorTag.c SensorTag.h SensorTag_Main.c
    ../../../TI/Profiles/SensorProfile/: thermoservice_usr.c thermoservice_usr.h
  group HAL/Common
    ../../../TI/Components/hal/common/: hal_drivers.c
  group HAL/Include
    ../../../TI/Components/hal/include/: hal_assert.h hal_board.h hal_defs.h hal_drivers.h hal_flash.h hal_key.h hal_lcd.h hal_led.h hal_sleep.h hal_timer.h hal_uart.h
    ../../../TI/Components/services/saddr/: saddr.h
  group HAL/Target/Config
    ../../../TI/Components/hal/target/CC2541ST/: hal_board_cfg.h
  group HAL/Target/Drivers
    ../../../TI/Components/hal/target/CC2541ST/: hal_acc.c hal_aes.c hal_assert.c hal_bar.c hal_crc.c hal_dma.c hal_flash.c hal_gyro.c hal_humi.c hal_i2c.c hal_interrupt.c hal_irtemp.c hal_keys.c hal_led.c hal_mag.c hal_sensor.c hal_sleep.c hal_startup.c hal_timer.c
  group HAL/Target/Includes
    ../../../TI/Components/hal/target/CC2541ST/: hal_acc.h hal_aes.h hal_bar.h hal_dma.h hal_gyro.h hal_humi.h hal_i2c.h hal_irtemp.h hal_keys.h hal_mag.h hal_mcu.h hal_sensor.h hal_types.h
  group LIB
    ../../../TI/Components/Libraries/CC2541DB/bin/: CC2541_BLE_peri.lib
    ../../../TI/Components/Libraries/Common/bin/: CC254x_BLE_HCI_TL_None.lib
  group NPI
    ../../../TI/Components/common/npi/npi_np/: npi.c npi.h
  group OSAL
    ../../../TI/Components/ble/include/: bcomdef.h
    ../../../TI/Components/osal/common/: OSAL.c osal_bufmgr.c osal_cbtimer.c OSAL_ClockBLE.c OSAL_Memory.c OSAL_PwrMgr.c OSAL_Timers.c
    ../../../TI/Components/osal/mcu/cc2540/: osal_snv.c
  group PROFILES
    ../../../TI/Profiles/SensorProfile/: accelerometerservice.c accelerometerservice.h barometerservice.c barometerservice.h bcservice.c bcservice.h ccservice.c ccservice.h gyroservice.c gyroservice.h humidityservice.c humidityservice.h irtempservice.c irtempservice.h magnetometerservice.c magnetometerservice.h st_util.c st_util.h testservice.c testservice.h
    ../Source/: devinfoservice-st.c devinfoservice-st.h
    ../../../TI/Profiles/Roles/: gap.c gapbondmgr.c gapbondmgr.h peripheral.c peripheral.h
    ../../../TI/Components/Include/: gapgattserver.h gattservapp.h
    ../../../TI/Components/ble/host/: gatt_uuid.c
    ../../../TI/Profiles/OAD/: oad.h oad_target.c oad_target.h
    ../../../TI/Profiles/Keys/: simplekeys.c simplekeys.h
  group TOOLS
    ../../../TI/Components/config/: buildComponents.cfg
    ./: buildConfig.cfg
    ../../../TI/Components/common/cc2540/: OnBoard.c OnBoard.h
