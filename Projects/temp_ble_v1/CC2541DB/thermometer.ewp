# IAR project thermometer.ewp, settings and files
configuration CC2541DK-MINI Keyfob Slave (8051, debug)
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\CC2541.i51
  ICC8051.CCDefines: INT_HEAP_LEN=2900; HALNODEBUG; OSAL_CBTIMER_NUM_TASKS=1; HAL_AES_DMA=TRUE; HAL_DMA=TRUE; POWER_SAVING; xPLUS_BROADCASTER; HAL_LCD=FALSE; HAL_LED=TRUE; CC2540_MINIDK
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: ..\..\..\TI\Components\common; ..\..\..\TI\Components\include; ..\..\..\TI\Components\hal\include; ..\..\..\TI\Components\hal\target\CC2540EB; ..\..\..\TI\Components\osal\include; ..\..\..\TI\Components\services\saddr; ..\..\..\TI\Components\ble\include; ..\..\..\TI\Components\ble\controller\phy; ..\..\..\TI\Components\ble\controller\include; ..\..\..\TI\Components\ble\hci; ..\..\..\TI\Components\ble\host; ..\..\..\TI\Components\common\cc2540; ..\..\..\TI\Profiles\Roles; ..\..\..\TI\Profiles\Thermometer; ..\..\..\TI\Profiles\DevInfo; ..\..\..\TI\Profiles\Batt
  ICC8051.CCOptLevel: 0
  ICC8051.CCOptStrategy: 1
  ICC8051.IccLang: 0
  XLINK.XclFile: ..\..\..\TI\Components\common\cc2540\ti_51ew_cc2540b.xcl
configuration CC2541 Slave (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: INT_HEAP_LEN=3008; HALNODEBUG; OSAL_CBTIMER_NUM_TASKS=1; HAL_AES_DMA=TRUE; HAL_DMA=TRUE; POWER_SAVING; xPLUS_BROADCASTER; HAL_LCD=TRUE; HAL_LED=TRUE
  group APP
    ../Source/: OSAL_thermometer.c thermometer.c thermometer.h thermometer_Main.c timeapp.h timeapp_clock.c timeapp_config.c timeapp_discovery.c timeapp_ind.c
  group HAL/Common
    ../../../TI/Components/hal/common/: hal_drivers.c
  group HAL/Include
    ../../../TI/Components/hal/include/: hal_adc.h hal_assert.h hal_board.h hal_defs.h hal_drivers.h hal_flash.h hal_key.h hal_lcd.h hal_led.h hal_rpc.h hal_sleep.h hal_timer.h hal_uart.h
    ../../../TI/Components/services/saddr/: saddr.h
  group HAL/Target/CC2540EB/Config
    ../../../TI/Components/hal/target/CC2540EB/: hal_board_cfg.h
  group HAL/Target/CC2540EB/Drivers
    ../../../TI/Components/hal/target/CC2540EB/: hal_adc.c hal_aes.c hal_dma.c hal_flash.c hal_key.c hal_lcd.c hal_led.c hal_sleep.c hal_startup.c hal_timer.c hal_uart.c
  group HAL/Target/CC2540EB/Includes
    ../../../TI/Components/hal/target/CC2540EB/: hal_aes.h hal_ccm.h hal_dma.h hal_mcu.h hal_types.h
  group INCLUDE
    ../../../TI/Components/ble/include/: att.h gap.h gatt.h gatt_uuid.h hci.h l2cap.h sm.h
    ../../../TI/Components/ble/host/: linkdb.h
    ../../../TI/Components/ble/controller/include/: ll.h phy.h
    ../../../TI/Components/common/npi/npi_np/: npi.h
  group LIB
    ../../../TI/Components/Libraries/CC2541DB/bin/: CC2541_BLE_peri.lib
    ../../../TI/Components/Libraries/Common/bin/: CC254x_BLE_HCI_TL_None.lib
  group NPI
    ../../../TI/Components/common/npi/npi_np/: npi.c npi_spi.c npi_uart.c
  group OSAL
    ../../../TI/Components/ble/include/: bcomdef.h
    ../../../TI/Components/osal/common/: OSAL.c osal_bufmgr.c osal_cbtimer.c OSAL_ClockBLE.c OSAL_Memory.c OSAL_PwrMgr.c OSAL_Timers.c
    ../../../TI/Components/osal/mcu/cc2540/: osal_snv.c
  group PROFILES
    ../../../TI/Profiles/DevInfo/: devinfoservice.c devinfoservice.h
    ../../../TI/Profiles/Roles/: gap.c gapbondmgr.c gapbondmgr.h peripheral.c peripheral.h
    ../../../TI/Components/include/: gapgattserver.h gattservapp.h
    ../../../TI/Components/ble/host/: gatt_uuid.c
    ../../../TI/Profiles/Thermometer/: thermometerservice.c thermometerservice.h
  group TOOLS
    ../../../TI/Components/config/: buildComponents.cfg
    ./: buildConfig.cfg
    ../../../TI/Components/common/cc2540/: OnBoard.c OnBoard.h
